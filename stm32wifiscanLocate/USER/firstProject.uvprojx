# Keil uVision project firstProject.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: firstProject +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F429xx
  c include: ..\SYSTEM\sys;..\SYSTEM\delay;..\SYSTEM\usart;..\WAYZ;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\USART3;..\HARDWARE\TIMER;..\HARDWARE\SDRAM
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f429xx.s
  group USER
    ./: main.c
  group SYSTEM
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group WAYZ
    ../WAYZ/: wayz.c zlog.c cJSON.c
  group HARDWARE
    ../HARDWARE/LCD/: lcd.c ltdc.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SDRAM/: sdram.c
